# Keil uVision project JXGF_V4.0.uvprojx, settings and files
target FLASH (ARM-ADS)
  device: LPC1788 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: JXGF_V4.0 +hex
  AfterMake: fromelf.exe --bin -o .\bin\JXGF_V4.bin  .\output\JXGF_V4.0
  c flags: Optim=1 wLevel=2
  c include: .\include;..\common\CoreSupport;..\common\DeviceSupport;..\common\Drivers\include
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000 size 0x70000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ../common/DeviceSupport/startup/: startup_LPC177x_8x.s
  group CMSIS-CM3
    ../common/CoreSupport/: core_cm3.c
    ../common/DeviceSupport/: system_LPC177x_8x.c
  group Drivers
    ../common/Drivers/source/: adc.c at24c512.c crc.c ctrl.c delay.c devicetest.c ds3232.c eeprom.c fm25l04.c fyd12864.c i2c0.c i2c1.c keyboard.c menu.c modbus.c mt318.c printer.c query.c rtc.c splc.c ssp.c sst25vf064c.c threedes.c turn.c uart.c
    ./include/: eleclabel.h
  group User
    ./src/: main.c lngctrl.c controlparas.c app.c password.c timer.c eleclabel.c
    ./: readme.txt
